VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO CHIP_ART_name
  CLASS BLOCK ;
  ORIGIN 0.000 0.000 ;
  FOREIGN CHIP_ART_name 0.000 0.000 ;
  SIZE 29.500 BY 15.000 ;
  SYMMETRY X Y R90 ;
  OBS
    LAYER met4 ;
      RECT 0.000 14.500 2.500 15.000 ;
      RECT 3.000 14.500 5.500 15.000 ;
      RECT 6.500 14.500 8.000 15.000 ;
      RECT 9.000 14.500 9.500 15.000 ;
      RECT 11.000 14.500 11.500 15.000 ;
      RECT 12.000 14.500 12.500 15.000 ;
      RECT 15.000 14.500 17.500 15.000 ;
      RECT 18.000 14.500 18.500 15.000 ;
      RECT 20.000 14.500 20.500 15.000 ;
      RECT 0.000 14.000 0.500 14.500 ;
      RECT 4.000 14.000 4.500 14.500 ;
      RECT 6.000 14.000 6.500 14.500 ;
      RECT 8.000 14.000 8.500 14.500 ;
      RECT 9.000 14.000 10.000 14.500 ;
      RECT 11.000 14.000 11.500 14.500 ;
      RECT 12.000 14.000 12.500 14.500 ;
      RECT 15.000 14.000 15.500 14.500 ;
      RECT 18.000 14.000 18.500 14.500 ;
      RECT 20.000 14.000 20.500 14.500 ;
      RECT 0.000 13.500 0.500 14.000 ;
      RECT 4.000 13.500 4.500 14.000 ;
      RECT 6.000 13.500 6.500 14.000 ;
      RECT 8.000 13.500 8.500 14.000 ;
      RECT 9.000 13.500 9.500 14.000 ;
      RECT 10.000 13.500 10.500 14.000 ;
      RECT 11.000 13.500 11.500 14.000 ;
      RECT 12.000 13.500 12.500 14.000 ;
      RECT 15.000 13.500 15.500 14.000 ;
      RECT 18.500 13.500 19.000 14.000 ;
      RECT 19.500 13.500 20.000 14.000 ;
      RECT 0.000 13.000 2.500 13.500 ;
      RECT 4.000 13.000 4.500 13.500 ;
      RECT 6.000 13.000 8.500 13.500 ;
      RECT 9.000 13.000 9.500 13.500 ;
      RECT 10.000 13.000 10.500 13.500 ;
      RECT 11.000 13.000 11.500 13.500 ;
      RECT 12.000 13.000 12.500 13.500 ;
      RECT 15.000 13.000 16.500 13.500 ;
      RECT 18.500 13.000 19.000 13.500 ;
      RECT 19.500 13.000 20.000 13.500 ;
      RECT 2.000 12.500 2.500 13.000 ;
      RECT 4.000 12.500 4.500 13.000 ;
      RECT 6.000 12.500 6.500 13.000 ;
      RECT 8.000 12.500 8.500 13.000 ;
      RECT 9.000 12.500 9.500 13.000 ;
      RECT 10.000 12.500 10.500 13.000 ;
      RECT 11.000 12.500 11.500 13.000 ;
      RECT 12.000 12.500 12.500 13.000 ;
      RECT 15.000 12.500 15.500 13.000 ;
      RECT 19.000 12.500 19.500 13.000 ;
      RECT 2.000 12.000 2.500 12.500 ;
      RECT 4.000 12.000 4.500 12.500 ;
      RECT 6.000 12.000 6.500 12.500 ;
      RECT 8.000 12.000 8.500 12.500 ;
      RECT 9.000 12.000 9.500 12.500 ;
      RECT 10.500 12.000 11.500 12.500 ;
      RECT 12.000 12.000 12.500 12.500 ;
      RECT 15.000 12.000 15.500 12.500 ;
      RECT 19.000 12.000 19.500 12.500 ;
      RECT 0.000 11.500 2.500 12.000 ;
      RECT 4.000 11.500 4.500 12.000 ;
      RECT 6.000 11.500 6.500 12.000 ;
      RECT 8.000 11.500 8.500 12.000 ;
      RECT 9.000 11.500 9.500 12.000 ;
      RECT 11.000 11.500 11.500 12.000 ;
      RECT 12.000 11.500 14.500 12.000 ;
      RECT 15.000 11.500 17.500 12.000 ;
      RECT 19.000 11.500 19.500 12.000 ;
      RECT 15.000 10.500 17.000 11.000 ;
      RECT 18.500 10.500 20.000 11.000 ;
      RECT 21.500 10.500 23.000 11.000 ;
      RECT 24.000 10.500 26.500 11.000 ;
      RECT 27.000 10.500 27.500 11.000 ;
      RECT 29.000 10.500 29.500 11.000 ;
      RECT 15.000 10.000 15.500 10.500 ;
      RECT 17.000 10.000 17.500 10.500 ;
      RECT 18.000 10.000 18.500 10.500 ;
      RECT 20.000 10.000 20.500 10.500 ;
      RECT 21.000 10.000 21.500 10.500 ;
      RECT 23.000 10.000 23.500 10.500 ;
      RECT 25.000 10.000 25.500 10.500 ;
      RECT 27.000 10.000 27.500 10.500 ;
      RECT 29.000 10.000 29.500 10.500 ;
      RECT 15.000 9.500 15.500 10.000 ;
      RECT 17.000 9.500 17.500 10.000 ;
      RECT 18.000 9.500 18.500 10.000 ;
      RECT 20.000 9.500 20.500 10.000 ;
      RECT 21.000 9.500 21.500 10.000 ;
      RECT 23.000 9.500 23.500 10.000 ;
      RECT 25.000 9.500 25.500 10.000 ;
      RECT 27.000 9.500 27.500 10.000 ;
      RECT 29.000 9.500 29.500 10.000 ;
      RECT 1.500 9.000 2.000 9.500 ;
      RECT 2.500 9.000 4.000 9.500 ;
      RECT 15.000 9.000 17.000 9.500 ;
      RECT 18.000 9.000 18.500 9.500 ;
      RECT 20.000 9.000 20.500 9.500 ;
      RECT 21.000 9.000 21.500 9.500 ;
      RECT 23.000 9.000 23.500 9.500 ;
      RECT 25.000 9.000 25.500 9.500 ;
      RECT 27.000 9.000 29.500 9.500 ;
      RECT 1.000 8.500 2.000 9.000 ;
      RECT 2.500 8.500 3.000 9.000 ;
      RECT 3.500 8.500 4.000 9.000 ;
      RECT 15.000 8.500 15.500 9.000 ;
      RECT 17.000 8.500 17.500 9.000 ;
      RECT 18.000 8.500 18.500 9.000 ;
      RECT 20.000 8.500 20.500 9.000 ;
      RECT 21.000 8.500 21.500 9.000 ;
      RECT 23.000 8.500 23.500 9.000 ;
      RECT 25.000 8.500 25.500 9.000 ;
      RECT 27.000 8.500 27.500 9.000 ;
      RECT 29.000 8.500 29.500 9.000 ;
      RECT 1.500 8.000 2.000 8.500 ;
      RECT 2.500 8.000 3.000 8.500 ;
      RECT 3.500 8.000 4.000 8.500 ;
      RECT 15.000 8.000 15.500 8.500 ;
      RECT 17.000 8.000 17.500 8.500 ;
      RECT 18.000 8.000 18.500 8.500 ;
      RECT 20.000 8.000 20.500 8.500 ;
      RECT 21.000 8.000 21.500 8.500 ;
      RECT 23.000 8.000 23.500 8.500 ;
      RECT 25.000 8.000 25.500 8.500 ;
      RECT 27.000 8.000 27.500 8.500 ;
      RECT 29.000 8.000 29.500 8.500 ;
      RECT 1.500 7.500 2.000 8.000 ;
      RECT 2.500 7.500 3.000 8.000 ;
      RECT 3.500 7.500 4.000 8.000 ;
      RECT 15.000 7.500 17.000 8.000 ;
      RECT 18.500 7.500 20.000 8.000 ;
      RECT 21.500 7.500 23.000 8.000 ;
      RECT 25.000 7.500 25.500 8.000 ;
      RECT 27.000 7.500 27.500 8.000 ;
      RECT 29.000 7.500 29.500 8.000 ;
      RECT 1.500 7.000 2.000 7.500 ;
      RECT 2.500 7.000 4.000 7.500 ;
      RECT 5.000 6.500 5.500 7.000 ;
      RECT 22.000 6.500 22.500 7.000 ;
      RECT 1.500 6.000 4.000 6.500 ;
      RECT 4.500 6.000 5.000 6.500 ;
      RECT 8.000 6.000 9.000 6.500 ;
      RECT 22.500 6.000 23.000 6.500 ;
      RECT 1.500 5.500 2.000 6.000 ;
      RECT 4.500 5.500 5.000 6.000 ;
      RECT 8.000 5.500 8.500 6.000 ;
      RECT 9.000 5.500 9.500 6.000 ;
      RECT 22.500 5.500 23.000 6.000 ;
      RECT 2.000 5.000 2.500 5.500 ;
      RECT 4.500 5.000 5.000 5.500 ;
      RECT 6.000 5.000 7.500 5.500 ;
      RECT 8.000 5.000 8.500 5.500 ;
      RECT 9.000 5.000 9.500 5.500 ;
      RECT 11.500 5.000 13.000 5.500 ;
      RECT 17.500 5.000 19.000 5.500 ;
      RECT 20.000 5.000 21.500 5.500 ;
      RECT 22.500 5.000 23.000 5.500 ;
      RECT 2.500 4.500 3.000 5.000 ;
      RECT 4.500 4.500 5.000 5.000 ;
      RECT 7.000 4.500 7.500 5.000 ;
      RECT 10.000 4.500 10.500 5.000 ;
      RECT 12.500 4.500 13.000 5.000 ;
      RECT 16.000 4.500 16.500 5.000 ;
      RECT 17.500 4.500 18.000 5.000 ;
      RECT 18.500 4.500 19.000 5.000 ;
      RECT 21.000 4.500 21.500 5.000 ;
      RECT 22.500 4.500 23.000 5.000 ;
      RECT 2.000 4.000 2.500 4.500 ;
      RECT 4.500 4.000 5.000 4.500 ;
      RECT 6.000 4.000 7.500 4.500 ;
      RECT 9.500 4.000 11.000 4.500 ;
      RECT 11.500 4.000 13.000 4.500 ;
      RECT 13.500 4.000 14.500 4.500 ;
      RECT 15.500 4.000 17.000 4.500 ;
      RECT 17.500 4.000 18.000 4.500 ;
      RECT 18.500 4.000 19.000 4.500 ;
      RECT 21.000 4.000 21.500 4.500 ;
      RECT 22.500 4.000 23.000 4.500 ;
      RECT 1.500 3.500 2.000 4.000 ;
      RECT 4.500 3.500 5.000 4.000 ;
      RECT 6.000 3.500 6.500 4.000 ;
      RECT 10.000 3.500 10.500 4.000 ;
      RECT 11.500 3.500 12.000 4.000 ;
      RECT 13.500 3.500 14.000 4.000 ;
      RECT 14.500 3.500 15.000 4.000 ;
      RECT 16.000 3.500 16.500 4.000 ;
      RECT 17.500 3.500 18.000 4.000 ;
      RECT 18.500 3.500 19.000 4.000 ;
      RECT 21.000 3.500 21.500 4.000 ;
      RECT 22.500 3.500 23.000 4.000 ;
      RECT 1.500 3.000 4.000 3.500 ;
      RECT 4.500 3.000 5.000 3.500 ;
      RECT 6.000 3.000 7.500 3.500 ;
      RECT 11.500 3.000 13.000 3.500 ;
      RECT 13.500 3.000 14.000 3.500 ;
      RECT 14.500 3.000 15.000 3.500 ;
      RECT 17.500 3.000 19.000 3.500 ;
      RECT 19.500 3.000 20.000 3.500 ;
      RECT 21.000 3.000 21.500 3.500 ;
      RECT 22.500 3.000 23.000 3.500 ;
      RECT 5.000 2.500 5.500 3.000 ;
      RECT 22.000 2.500 22.500 3.000 ;
      RECT 2.500 2.000 3.000 2.500 ;
      RECT 2.000 1.500 3.000 2.000 ;
      RECT 2.500 1.000 3.000 1.500 ;
      RECT 2.500 0.500 3.000 1.000 ;
      RECT 2.500 0.000 3.000 0.500 ;
  END
END CHIP_ART_name

END LIBRARY
