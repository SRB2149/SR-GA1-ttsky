VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO CHIP_ART_initials
  CLASS BLOCK ;
  ORIGIN 0.000 0.000 ;
  FOREIGN CHIP_ART_initials 0.000 0.000 ;
  SIZE 28.000 BY 14.700 ;
  SYMMETRY X Y R90 ;
  OBS
    LAYER met4 ;
      RECT 5.250 14.350 10.850 14.700 ;
      RECT 13.650 14.350 19.250 14.700 ;
      RECT 22.050 14.350 27.650 14.700 ;
      RECT 5.250 14.000 10.850 14.350 ;
      RECT 13.650 14.000 19.250 14.350 ;
      RECT 22.050 14.000 27.650 14.350 ;
      RECT 4.900 13.650 6.650 14.000 ;
      RECT 13.300 13.650 15.050 14.000 ;
      RECT 19.250 13.650 19.600 14.000 ;
      RECT 21.700 13.650 23.450 14.000 ;
      RECT 27.650 13.650 28.000 14.000 ;
      RECT 4.900 13.300 6.650 13.650 ;
      RECT 13.300 13.300 15.050 13.650 ;
      RECT 19.250 13.300 19.600 13.650 ;
      RECT 21.700 13.300 23.450 13.650 ;
      RECT 27.650 13.300 28.000 13.650 ;
      RECT 4.550 12.950 6.300 13.300 ;
      RECT 12.950 12.950 14.700 13.300 ;
      RECT 18.900 12.950 19.250 13.300 ;
      RECT 21.350 12.950 23.100 13.300 ;
      RECT 27.300 12.950 27.650 13.300 ;
      RECT 4.550 12.600 6.300 12.950 ;
      RECT 12.950 12.600 14.700 12.950 ;
      RECT 18.900 12.600 19.250 12.950 ;
      RECT 21.350 12.600 23.100 12.950 ;
      RECT 27.300 12.600 27.650 12.950 ;
      RECT 4.200 12.250 5.950 12.600 ;
      RECT 12.950 12.250 14.700 12.600 ;
      RECT 18.550 12.250 18.900 12.600 ;
      RECT 21.350 12.250 23.100 12.600 ;
      RECT 26.950 12.250 27.300 12.600 ;
      RECT 4.200 11.900 5.950 12.250 ;
      RECT 12.600 11.900 14.350 12.250 ;
      RECT 18.550 11.900 18.900 12.250 ;
      RECT 21.000 11.900 22.750 12.250 ;
      RECT 26.950 11.900 27.300 12.250 ;
      RECT 4.200 11.550 5.950 11.900 ;
      RECT 12.600 11.550 14.350 11.900 ;
      RECT 18.550 11.550 18.900 11.900 ;
      RECT 21.000 11.550 22.750 11.900 ;
      RECT 26.950 11.550 27.300 11.900 ;
      RECT 3.850 11.200 5.600 11.550 ;
      RECT 12.250 11.200 14.000 11.550 ;
      RECT 18.200 11.200 18.550 11.550 ;
      RECT 20.650 11.200 22.400 11.550 ;
      RECT 26.600 11.200 26.950 11.550 ;
      RECT 3.850 10.850 5.600 11.200 ;
      RECT 12.250 10.850 14.000 11.200 ;
      RECT 18.200 10.850 18.550 11.200 ;
      RECT 20.650 10.850 22.400 11.200 ;
      RECT 26.600 10.850 26.950 11.200 ;
      RECT 3.500 10.500 5.250 10.850 ;
      RECT 12.250 10.500 14.000 10.850 ;
      RECT 17.850 10.500 18.200 10.850 ;
      RECT 20.650 10.500 22.400 10.850 ;
      RECT 26.250 10.500 26.600 10.850 ;
      RECT 3.500 10.150 5.250 10.500 ;
      RECT 11.900 10.150 13.650 10.500 ;
      RECT 17.850 10.150 18.200 10.500 ;
      RECT 20.300 10.150 22.050 10.500 ;
      RECT 26.250 10.150 26.600 10.500 ;
      RECT 3.500 9.800 5.250 10.150 ;
      RECT 11.900 9.800 13.650 10.150 ;
      RECT 17.850 9.800 18.200 10.150 ;
      RECT 20.300 9.800 22.050 10.150 ;
      RECT 26.250 9.800 26.600 10.150 ;
      RECT 3.150 9.450 4.900 9.800 ;
      RECT 11.900 9.450 13.650 9.800 ;
      RECT 17.500 9.450 17.850 9.800 ;
      RECT 20.300 9.450 22.050 9.800 ;
      RECT 25.900 9.450 26.250 9.800 ;
      RECT 3.150 9.100 4.900 9.450 ;
      RECT 11.550 9.100 13.300 9.450 ;
      RECT 17.500 9.100 17.850 9.450 ;
      RECT 19.950 9.100 21.700 9.450 ;
      RECT 25.900 9.100 26.250 9.450 ;
      RECT 2.800 8.750 4.550 9.100 ;
      RECT 11.550 8.750 13.300 9.100 ;
      RECT 17.150 8.750 17.500 9.100 ;
      RECT 19.950 8.750 21.700 9.100 ;
      RECT 25.550 8.750 25.900 9.100 ;
      RECT 2.800 8.400 4.550 8.750 ;
      RECT 11.550 8.400 13.300 8.750 ;
      RECT 17.150 8.400 17.500 8.750 ;
      RECT 19.950 8.400 21.700 8.750 ;
      RECT 25.550 8.400 25.900 8.750 ;
      RECT 3.150 8.050 8.750 8.400 ;
      RECT 11.200 8.050 17.150 8.400 ;
      RECT 19.600 8.050 25.550 8.400 ;
      RECT 3.150 7.700 8.750 8.050 ;
      RECT 11.200 7.700 17.150 8.050 ;
      RECT 19.600 7.700 25.550 8.050 ;
      RECT 7.350 7.350 9.100 7.700 ;
      RECT 10.850 7.350 13.650 7.700 ;
      RECT 19.250 7.350 21.000 7.700 ;
      RECT 25.550 7.350 25.900 7.700 ;
      RECT 7.350 7.000 9.100 7.350 ;
      RECT 10.850 7.000 13.650 7.350 ;
      RECT 19.250 7.000 21.000 7.350 ;
      RECT 25.550 7.000 25.900 7.350 ;
      RECT 7.000 6.650 8.750 7.000 ;
      RECT 10.850 6.650 14.000 7.000 ;
      RECT 19.250 6.650 21.000 7.000 ;
      RECT 25.200 6.650 25.550 7.000 ;
      RECT 7.000 6.300 8.750 6.650 ;
      RECT 10.500 6.300 12.250 6.650 ;
      RECT 12.600 6.300 14.000 6.650 ;
      RECT 18.900 6.300 20.650 6.650 ;
      RECT 25.200 6.300 25.550 6.650 ;
      RECT 6.650 5.950 8.400 6.300 ;
      RECT 10.500 5.950 12.250 6.300 ;
      RECT 12.950 5.950 14.350 6.300 ;
      RECT 18.900 5.950 20.650 6.300 ;
      RECT 24.850 5.950 25.200 6.300 ;
      RECT 6.650 5.600 8.400 5.950 ;
      RECT 10.500 5.600 12.250 5.950 ;
      RECT 12.950 5.600 14.350 5.950 ;
      RECT 18.900 5.600 20.650 5.950 ;
      RECT 24.850 5.600 25.200 5.950 ;
      RECT 6.650 5.250 8.400 5.600 ;
      RECT 10.150 5.250 11.900 5.600 ;
      RECT 12.950 5.250 14.350 5.600 ;
      RECT 18.550 5.250 20.300 5.600 ;
      RECT 24.850 5.250 25.200 5.600 ;
      RECT 6.300 4.900 8.050 5.250 ;
      RECT 10.150 4.900 11.900 5.250 ;
      RECT 13.300 4.900 14.700 5.250 ;
      RECT 18.550 4.900 20.300 5.250 ;
      RECT 24.500 4.900 24.850 5.250 ;
      RECT 6.300 4.550 8.050 4.900 ;
      RECT 10.150 4.550 11.900 4.900 ;
      RECT 13.300 4.550 14.700 4.900 ;
      RECT 18.550 4.550 20.300 4.900 ;
      RECT 24.500 4.550 24.850 4.900 ;
      RECT 5.950 4.200 7.700 4.550 ;
      RECT 9.800 4.200 11.550 4.550 ;
      RECT 13.650 4.200 15.050 4.550 ;
      RECT 18.200 4.200 19.950 4.550 ;
      RECT 24.150 4.200 24.500 4.550 ;
      RECT 5.950 3.850 7.700 4.200 ;
      RECT 9.800 3.850 11.550 4.200 ;
      RECT 13.650 3.850 15.050 4.200 ;
      RECT 18.200 3.850 19.950 4.200 ;
      RECT 24.150 3.850 24.500 4.200 ;
      RECT 5.950 3.500 7.700 3.850 ;
      RECT 9.450 3.500 11.200 3.850 ;
      RECT 14.000 3.500 15.400 3.850 ;
      RECT 17.850 3.500 19.600 3.850 ;
      RECT 24.150 3.500 24.500 3.850 ;
      RECT 5.600 3.150 7.350 3.500 ;
      RECT 9.450 3.150 11.200 3.500 ;
      RECT 14.000 3.150 15.400 3.500 ;
      RECT 17.850 3.150 19.600 3.500 ;
      RECT 23.800 3.150 24.150 3.500 ;
      RECT 5.600 2.800 7.350 3.150 ;
      RECT 9.450 2.800 11.200 3.150 ;
      RECT 14.000 2.800 15.400 3.150 ;
      RECT 17.850 2.800 19.600 3.150 ;
      RECT 23.800 2.800 24.150 3.150 ;
      RECT 5.250 2.450 7.000 2.800 ;
      RECT 9.100 2.450 10.850 2.800 ;
      RECT 14.350 2.450 15.750 2.800 ;
      RECT 17.500 2.450 19.250 2.800 ;
      RECT 23.450 2.450 23.800 2.800 ;
      RECT 5.250 2.100 7.000 2.450 ;
      RECT 9.100 2.100 10.850 2.450 ;
      RECT 14.350 2.100 15.750 2.450 ;
      RECT 17.500 2.100 19.250 2.450 ;
      RECT 23.450 2.100 23.800 2.450 ;
      RECT 1.050 1.750 6.650 2.100 ;
      RECT 9.100 1.750 10.500 2.100 ;
      RECT 14.700 1.750 16.100 2.100 ;
      RECT 17.500 1.750 23.450 2.100 ;
      RECT 1.050 1.400 6.650 1.750 ;
      RECT 9.100 1.400 10.500 1.750 ;
      RECT 14.700 1.400 16.100 1.750 ;
      RECT 17.500 1.400 23.450 1.750 ;
      RECT 24.150 1.400 24.850 1.750 ;
      RECT 24.150 1.050 25.200 1.400 ;
      RECT 24.500 0.700 25.550 1.050 ;
      RECT 0.000 0.350 25.900 0.700 ;
      RECT 0.000 0.000 26.250 0.350 ;
  END
END CHIP_ART_initials

END LIBRARY
