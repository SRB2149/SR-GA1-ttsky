VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO CHIP_ART_logo
  CLASS BLOCK ;
  ORIGIN 0.000 0.000 ;
  FOREIGN CHIP_ART_logo 0.000 0.000 ;
  SIZE 46.200 BY 14.700 ;
  SYMMETRY X Y R90 ;
  OBS
    LAYER met4 ;
      RECT 5.250 14.350 10.850 14.700 ;
      RECT 13.650 14.350 19.250 14.700 ;
      RECT 27.650 14.350 33.250 14.700 ;
      RECT 38.850 14.350 39.200 14.700 ;
      RECT 44.800 14.350 46.200 14.700 ;
      RECT 5.250 14.000 10.850 14.350 ;
      RECT 13.650 14.000 19.250 14.350 ;
      RECT 27.650 14.000 33.250 14.350 ;
      RECT 35.000 14.000 42.350 14.350 ;
      RECT 44.800 14.000 46.200 14.350 ;
      RECT 4.900 13.650 6.650 14.000 ;
      RECT 13.300 13.650 15.050 14.000 ;
      RECT 19.250 13.650 19.600 14.000 ;
      RECT 27.300 13.650 29.050 14.000 ;
      RECT 38.850 13.650 39.200 14.000 ;
      RECT 44.450 13.650 46.200 14.000 ;
      RECT 4.900 13.300 6.650 13.650 ;
      RECT 13.300 13.300 15.050 13.650 ;
      RECT 19.250 13.300 19.600 13.650 ;
      RECT 27.300 13.300 29.050 13.650 ;
      RECT 35.350 13.300 37.100 13.650 ;
      RECT 38.850 13.300 39.200 13.650 ;
      RECT 39.900 13.300 41.650 13.650 ;
      RECT 44.450 13.300 46.200 13.650 ;
      RECT 4.550 12.950 6.300 13.300 ;
      RECT 12.950 12.950 14.700 13.300 ;
      RECT 18.900 12.950 19.250 13.300 ;
      RECT 26.950 12.950 28.700 13.300 ;
      RECT 35.000 12.950 37.450 13.300 ;
      RECT 38.500 12.950 38.850 13.300 ;
      RECT 39.550 12.950 42.000 13.300 ;
      RECT 44.100 12.950 45.850 13.300 ;
      RECT 4.550 12.600 6.300 12.950 ;
      RECT 12.950 12.600 14.700 12.950 ;
      RECT 18.900 12.600 19.250 12.950 ;
      RECT 26.950 12.600 28.700 12.950 ;
      RECT 35.000 12.600 35.700 12.950 ;
      RECT 36.750 12.600 37.450 12.950 ;
      RECT 38.500 12.600 38.850 12.950 ;
      RECT 39.200 12.600 39.900 12.950 ;
      RECT 41.300 12.600 42.000 12.950 ;
      RECT 44.100 12.600 45.850 12.950 ;
      RECT 4.200 12.250 5.950 12.600 ;
      RECT 12.950 12.250 14.700 12.600 ;
      RECT 18.550 12.250 18.900 12.600 ;
      RECT 26.950 12.250 28.700 12.600 ;
      RECT 34.650 12.250 35.350 12.600 ;
      RECT 36.750 12.250 37.450 12.600 ;
      RECT 38.150 12.250 38.500 12.600 ;
      RECT 39.200 12.250 39.900 12.600 ;
      RECT 41.300 12.250 42.000 12.600 ;
      RECT 44.100 12.250 45.850 12.600 ;
      RECT 4.200 11.900 5.950 12.250 ;
      RECT 12.600 11.900 14.350 12.250 ;
      RECT 18.550 11.900 18.900 12.250 ;
      RECT 26.600 11.900 28.350 12.250 ;
      RECT 34.650 11.900 35.350 12.250 ;
      RECT 36.750 11.900 37.450 12.250 ;
      RECT 38.150 11.900 38.500 12.250 ;
      RECT 38.850 11.900 39.550 12.250 ;
      RECT 40.950 11.900 41.650 12.250 ;
      RECT 43.750 11.900 45.500 12.250 ;
      RECT 4.200 11.550 5.950 11.900 ;
      RECT 12.600 11.550 14.350 11.900 ;
      RECT 18.550 11.550 18.900 11.900 ;
      RECT 26.600 11.550 28.350 11.900 ;
      RECT 34.300 11.550 35.000 11.900 ;
      RECT 36.400 11.550 37.100 11.900 ;
      RECT 38.150 11.550 38.500 11.900 ;
      RECT 38.850 11.550 39.550 11.900 ;
      RECT 40.950 11.550 41.650 11.900 ;
      RECT 43.750 11.550 45.500 11.900 ;
      RECT 3.850 11.200 5.600 11.550 ;
      RECT 12.250 11.200 14.000 11.550 ;
      RECT 18.200 11.200 18.550 11.550 ;
      RECT 26.250 11.200 28.000 11.550 ;
      RECT 34.300 11.200 37.100 11.550 ;
      RECT 37.800 11.200 38.150 11.550 ;
      RECT 38.850 11.200 41.650 11.550 ;
      RECT 43.400 11.200 45.150 11.550 ;
      RECT 3.850 10.850 5.600 11.200 ;
      RECT 12.250 10.850 14.000 11.200 ;
      RECT 18.200 10.850 18.550 11.200 ;
      RECT 26.250 10.850 28.000 11.200 ;
      RECT 34.300 10.850 37.100 11.200 ;
      RECT 37.800 10.850 38.150 11.200 ;
      RECT 38.500 10.850 41.300 11.200 ;
      RECT 43.400 10.850 45.150 11.200 ;
      RECT 3.500 10.500 5.250 10.850 ;
      RECT 12.250 10.500 14.000 10.850 ;
      RECT 17.850 10.500 18.200 10.850 ;
      RECT 26.250 10.500 28.000 10.850 ;
      RECT 33.950 10.500 36.750 10.850 ;
      RECT 37.450 10.500 37.800 10.850 ;
      RECT 38.500 10.500 41.300 10.850 ;
      RECT 43.400 10.500 45.150 10.850 ;
      RECT 3.500 10.150 5.250 10.500 ;
      RECT 11.900 10.150 13.650 10.500 ;
      RECT 17.850 10.150 18.200 10.500 ;
      RECT 25.900 10.150 27.650 10.500 ;
      RECT 33.950 10.150 34.650 10.500 ;
      RECT 36.050 10.150 36.750 10.500 ;
      RECT 37.450 10.150 37.800 10.500 ;
      RECT 38.500 10.150 39.200 10.500 ;
      RECT 40.600 10.150 41.300 10.500 ;
      RECT 43.050 10.150 44.800 10.500 ;
      RECT 3.500 9.800 5.250 10.150 ;
      RECT 11.900 9.800 13.650 10.150 ;
      RECT 17.850 9.800 18.200 10.150 ;
      RECT 25.900 9.800 27.650 10.150 ;
      RECT 33.950 9.800 34.650 10.150 ;
      RECT 36.050 9.800 36.750 10.150 ;
      RECT 37.450 9.800 37.800 10.150 ;
      RECT 38.150 9.800 38.850 10.150 ;
      RECT 40.250 9.800 40.950 10.150 ;
      RECT 43.050 9.800 44.800 10.150 ;
      RECT 3.150 9.450 4.900 9.800 ;
      RECT 11.900 9.450 13.650 9.800 ;
      RECT 17.500 9.450 17.850 9.800 ;
      RECT 25.900 9.450 27.650 9.800 ;
      RECT 33.600 9.450 34.300 9.800 ;
      RECT 35.700 9.450 36.400 9.800 ;
      RECT 37.100 9.450 37.450 9.800 ;
      RECT 38.150 9.450 38.850 9.800 ;
      RECT 40.250 9.450 40.950 9.800 ;
      RECT 43.050 9.450 44.800 9.800 ;
      RECT 3.150 9.100 4.900 9.450 ;
      RECT 11.550 9.100 13.300 9.450 ;
      RECT 17.500 9.100 17.850 9.450 ;
      RECT 25.550 9.100 27.300 9.450 ;
      RECT 33.600 9.100 34.300 9.450 ;
      RECT 35.700 9.100 36.400 9.450 ;
      RECT 37.100 9.100 37.450 9.450 ;
      RECT 37.800 9.100 38.500 9.450 ;
      RECT 39.900 9.100 40.600 9.450 ;
      RECT 42.700 9.100 44.450 9.450 ;
      RECT 2.800 8.750 4.550 9.100 ;
      RECT 11.550 8.750 13.300 9.100 ;
      RECT 17.150 8.750 17.500 9.100 ;
      RECT 25.550 8.750 27.300 9.100 ;
      RECT 33.250 8.750 33.950 9.100 ;
      RECT 35.350 8.750 36.050 9.100 ;
      RECT 36.750 8.750 37.100 9.100 ;
      RECT 37.800 8.750 38.500 9.100 ;
      RECT 39.900 8.750 40.600 9.100 ;
      RECT 42.700 8.750 44.450 9.100 ;
      RECT 2.800 8.400 4.550 8.750 ;
      RECT 11.550 8.400 13.300 8.750 ;
      RECT 17.150 8.400 17.500 8.750 ;
      RECT 19.600 8.400 23.450 8.750 ;
      RECT 25.550 8.400 27.300 8.750 ;
      RECT 33.250 8.400 33.950 8.750 ;
      RECT 35.350 8.400 36.050 8.750 ;
      RECT 36.750 8.400 37.100 8.750 ;
      RECT 42.700 8.400 44.450 8.750 ;
      RECT 3.150 8.050 8.750 8.400 ;
      RECT 11.200 8.050 17.150 8.400 ;
      RECT 19.250 8.050 23.100 8.400 ;
      RECT 25.200 8.050 26.950 8.400 ;
      RECT 28.350 8.050 31.150 8.400 ;
      RECT 36.750 8.050 40.950 8.400 ;
      RECT 42.350 8.050 44.100 8.400 ;
      RECT 3.150 7.700 8.750 8.050 ;
      RECT 11.200 7.700 17.150 8.050 ;
      RECT 19.250 7.700 23.100 8.050 ;
      RECT 25.200 7.700 26.950 8.050 ;
      RECT 28.700 7.700 31.150 8.050 ;
      RECT 32.900 7.700 36.750 8.050 ;
      RECT 42.350 7.700 44.100 8.050 ;
      RECT 7.350 7.350 9.100 7.700 ;
      RECT 10.850 7.350 13.650 7.700 ;
      RECT 18.900 7.350 22.750 7.700 ;
      RECT 24.850 7.350 26.600 7.700 ;
      RECT 29.750 7.350 31.500 7.700 ;
      RECT 36.400 7.350 36.750 7.700 ;
      RECT 37.450 7.350 39.200 7.700 ;
      RECT 42.000 7.350 43.750 7.700 ;
      RECT 7.350 7.000 9.100 7.350 ;
      RECT 10.850 7.000 13.650 7.350 ;
      RECT 24.850 7.000 26.600 7.350 ;
      RECT 29.750 7.000 31.500 7.350 ;
      RECT 33.250 7.000 35.000 7.350 ;
      RECT 36.400 7.000 36.750 7.350 ;
      RECT 37.100 7.000 39.550 7.350 ;
      RECT 42.000 7.000 43.750 7.350 ;
      RECT 7.000 6.650 8.750 7.000 ;
      RECT 10.850 6.650 14.000 7.000 ;
      RECT 24.850 6.650 26.600 7.000 ;
      RECT 29.400 6.650 31.150 7.000 ;
      RECT 32.900 6.650 35.350 7.000 ;
      RECT 36.050 6.650 36.400 7.000 ;
      RECT 37.100 6.650 37.800 7.000 ;
      RECT 38.850 6.650 39.550 7.000 ;
      RECT 42.000 6.650 43.750 7.000 ;
      RECT 7.000 6.300 8.750 6.650 ;
      RECT 10.500 6.300 12.250 6.650 ;
      RECT 12.600 6.300 14.000 6.650 ;
      RECT 24.500 6.300 26.250 6.650 ;
      RECT 29.400 6.300 31.150 6.650 ;
      RECT 32.550 6.300 33.250 6.650 ;
      RECT 34.650 6.300 35.350 6.650 ;
      RECT 36.050 6.300 36.400 6.650 ;
      RECT 36.750 6.300 37.450 6.650 ;
      RECT 38.850 6.300 39.550 6.650 ;
      RECT 41.650 6.300 43.400 6.650 ;
      RECT 6.650 5.950 8.400 6.300 ;
      RECT 10.500 5.950 12.250 6.300 ;
      RECT 12.950 5.950 14.350 6.300 ;
      RECT 24.500 5.950 26.250 6.300 ;
      RECT 29.050 5.950 30.800 6.300 ;
      RECT 32.550 5.950 33.250 6.300 ;
      RECT 34.650 5.950 35.350 6.300 ;
      RECT 35.700 5.950 36.050 6.300 ;
      RECT 36.750 5.950 37.450 6.300 ;
      RECT 38.850 5.950 39.550 6.300 ;
      RECT 41.650 5.950 43.400 6.300 ;
      RECT 6.650 5.600 8.400 5.950 ;
      RECT 10.500 5.600 12.250 5.950 ;
      RECT 12.950 5.600 14.350 5.950 ;
      RECT 24.500 5.600 26.250 5.950 ;
      RECT 29.050 5.600 30.800 5.950 ;
      RECT 32.200 5.600 32.900 5.950 ;
      RECT 34.300 5.600 35.000 5.950 ;
      RECT 35.700 5.600 36.050 5.950 ;
      RECT 36.400 5.600 37.100 5.950 ;
      RECT 38.500 5.600 39.200 5.950 ;
      RECT 41.650 5.600 43.400 5.950 ;
      RECT 6.650 5.250 8.400 5.600 ;
      RECT 10.150 5.250 11.900 5.600 ;
      RECT 12.950 5.250 14.350 5.600 ;
      RECT 24.150 5.250 25.900 5.600 ;
      RECT 29.050 5.250 30.800 5.600 ;
      RECT 32.200 5.250 32.900 5.600 ;
      RECT 34.300 5.250 35.000 5.600 ;
      RECT 35.700 5.250 36.050 5.600 ;
      RECT 36.400 5.250 39.200 5.600 ;
      RECT 41.300 5.250 43.050 5.600 ;
      RECT 6.300 4.900 8.050 5.250 ;
      RECT 10.150 4.900 11.900 5.250 ;
      RECT 13.300 4.900 14.700 5.250 ;
      RECT 24.150 4.900 25.900 5.250 ;
      RECT 28.700 4.900 30.450 5.250 ;
      RECT 32.200 4.900 35.000 5.250 ;
      RECT 35.350 4.900 35.700 5.250 ;
      RECT 36.400 4.900 39.200 5.250 ;
      RECT 41.300 4.900 43.050 5.250 ;
      RECT 6.300 4.550 8.050 4.900 ;
      RECT 10.150 4.550 11.900 4.900 ;
      RECT 13.300 4.550 14.700 4.900 ;
      RECT 24.150 4.550 25.900 4.900 ;
      RECT 28.700 4.550 30.450 4.900 ;
      RECT 31.850 4.550 34.650 4.900 ;
      RECT 35.350 4.550 35.700 4.900 ;
      RECT 36.050 4.550 38.850 4.900 ;
      RECT 41.300 4.550 43.050 4.900 ;
      RECT 5.950 4.200 7.700 4.550 ;
      RECT 9.800 4.200 11.550 4.550 ;
      RECT 13.650 4.200 15.050 4.550 ;
      RECT 23.800 4.200 25.550 4.550 ;
      RECT 28.350 4.200 30.100 4.550 ;
      RECT 31.850 4.200 34.650 4.550 ;
      RECT 35.000 4.200 35.350 4.550 ;
      RECT 36.050 4.200 36.750 4.550 ;
      RECT 38.150 4.200 38.850 4.550 ;
      RECT 40.950 4.200 42.700 4.550 ;
      RECT 5.950 3.850 7.700 4.200 ;
      RECT 9.800 3.850 11.550 4.200 ;
      RECT 13.650 3.850 15.050 4.200 ;
      RECT 23.800 3.850 25.550 4.200 ;
      RECT 28.350 3.850 30.100 4.200 ;
      RECT 31.850 3.850 32.550 4.200 ;
      RECT 33.950 3.850 34.650 4.200 ;
      RECT 35.000 3.850 35.350 4.200 ;
      RECT 36.050 3.850 36.750 4.200 ;
      RECT 38.150 3.850 38.850 4.200 ;
      RECT 40.950 3.850 42.700 4.200 ;
      RECT 5.950 3.500 7.700 3.850 ;
      RECT 9.450 3.500 11.200 3.850 ;
      RECT 14.000 3.500 15.400 3.850 ;
      RECT 23.450 3.500 25.200 3.850 ;
      RECT 28.350 3.500 30.100 3.850 ;
      RECT 31.500 3.500 32.200 3.850 ;
      RECT 33.600 3.500 34.300 3.850 ;
      RECT 35.000 3.500 35.350 3.850 ;
      RECT 35.700 3.500 36.400 3.850 ;
      RECT 37.800 3.500 38.500 3.850 ;
      RECT 40.600 3.500 42.350 3.850 ;
      RECT 5.600 3.150 7.350 3.500 ;
      RECT 9.450 3.150 11.200 3.500 ;
      RECT 14.000 3.150 15.400 3.500 ;
      RECT 23.450 3.150 25.200 3.500 ;
      RECT 28.000 3.150 29.750 3.500 ;
      RECT 31.500 3.150 32.200 3.500 ;
      RECT 33.600 3.150 34.300 3.500 ;
      RECT 34.650 3.150 35.000 3.500 ;
      RECT 35.700 3.150 36.400 3.500 ;
      RECT 37.800 3.150 38.500 3.500 ;
      RECT 40.600 3.150 42.350 3.500 ;
      RECT 5.600 2.800 7.350 3.150 ;
      RECT 9.450 2.800 11.200 3.150 ;
      RECT 14.000 2.800 15.400 3.150 ;
      RECT 23.450 2.800 25.200 3.150 ;
      RECT 28.000 2.800 29.750 3.150 ;
      RECT 31.150 2.800 31.850 3.150 ;
      RECT 33.250 2.800 33.950 3.150 ;
      RECT 34.650 2.800 35.000 3.150 ;
      RECT 35.350 2.800 36.050 3.150 ;
      RECT 37.450 2.800 38.150 3.150 ;
      RECT 40.600 2.800 42.350 3.150 ;
      RECT 5.250 2.450 7.000 2.800 ;
      RECT 9.100 2.450 10.850 2.800 ;
      RECT 14.350 2.450 15.750 2.800 ;
      RECT 23.100 2.450 24.850 2.800 ;
      RECT 27.650 2.450 29.400 2.800 ;
      RECT 31.150 2.450 31.850 2.800 ;
      RECT 33.250 2.450 33.950 2.800 ;
      RECT 34.300 2.450 34.650 2.800 ;
      RECT 35.350 2.450 36.050 2.800 ;
      RECT 37.450 2.450 38.150 2.800 ;
      RECT 40.250 2.450 42.000 2.800 ;
      RECT 5.250 2.100 7.000 2.450 ;
      RECT 9.100 2.100 10.850 2.450 ;
      RECT 14.350 2.100 15.750 2.450 ;
      RECT 23.100 2.100 24.850 2.450 ;
      RECT 27.650 2.100 29.400 2.450 ;
      RECT 34.300 2.100 34.650 2.450 ;
      RECT 40.250 2.100 42.000 2.450 ;
      RECT 1.050 1.750 6.650 2.100 ;
      RECT 9.100 1.750 10.500 2.100 ;
      RECT 14.700 1.750 16.100 2.100 ;
      RECT 23.100 1.750 28.700 2.100 ;
      RECT 30.800 1.750 38.500 2.100 ;
      RECT 40.250 1.750 41.650 2.100 ;
      RECT 1.050 1.400 6.650 1.750 ;
      RECT 9.100 1.400 10.500 1.750 ;
      RECT 14.700 1.400 16.100 1.750 ;
      RECT 23.100 1.400 28.700 1.750 ;
      RECT 34.300 1.400 34.650 1.750 ;
      RECT 40.250 1.400 41.650 1.750 ;
      RECT 44.100 1.400 44.800 1.750 ;
      RECT 44.100 1.050 45.150 1.400 ;
      RECT 44.450 0.700 45.500 1.050 ;
      RECT 0.000 0.350 45.850 0.700 ;
      RECT 0.000 0.000 46.200 0.350 ;
  END
END CHIP_ART_logo

END LIBRARY
